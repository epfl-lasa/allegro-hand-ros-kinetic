Commit message: visualization corrected

File: src/allegro_hand_description/allegro_hand_description_left_iason.urdf (robot description, URDF)
Before this commit: robot allegro_hand_left, 22 links, 21 joints
Joints:
- joint joint_11: origin xyz=0 0 0.0384 -> xyz=0 0 0.0384 rpy=0 0 0
